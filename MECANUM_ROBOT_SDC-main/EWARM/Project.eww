<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PS4+STM32+ESP.ewp</path>
  </project>
  <batchBuild />
</workspace>
