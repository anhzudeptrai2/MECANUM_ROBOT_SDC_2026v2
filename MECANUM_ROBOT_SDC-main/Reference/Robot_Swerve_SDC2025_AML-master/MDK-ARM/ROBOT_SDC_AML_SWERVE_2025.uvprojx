# Keil uVision project ROBOT_SDC_AML_SWERVE_2025.uvprojx, settings and files
target ROBOT_SDC_AML_SWERVE_2025 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: ROBOT_SDC_AML_SWERVE_2025 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32H743xx,STM32H7
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Inc/: CRC_16.h DRIVER_PID_AML.h NEXTION_HMI.h PID.h PS4_ESP.h TIMER_TIMEOUT.h WT901C.h SWERVE_X4_KINEMATIC.h ROBOT_ACCELERATION.h SICK_DT50.h TACTILE.h ENCODER.h WAYPOINTS.h
    ../Core/Src/: CRC_16.c DRIVER_PID_AML.c NEXTION_HMI.c PID.c PS4_ESP.c TIMER_TIMEOUT.c WT901C.c SWERVE_X4_KINEMATIC.c ROBOT_ACCELERATION.c main.c stm32h7xx_it.c stm32h7xx_hal_msp.c SICK_DT50.c TACTILE.c ENCODER.c WAYPOINTS.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.4.0
